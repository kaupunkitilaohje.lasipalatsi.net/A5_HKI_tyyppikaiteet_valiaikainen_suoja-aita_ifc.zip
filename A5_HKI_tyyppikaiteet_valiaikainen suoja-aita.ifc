Properties of the parts of a building model (IFC2X3)

# File
Description: IFC 2x3 Building Model
Time: 2021-12-28T15:22:49
Author: Vaarna, Verna
Organization: WSP
Made in: ASIFC - 2.11.0.854

# IfcSite, Site
RefElevation: 0 mm
